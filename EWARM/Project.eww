<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Candy_Bugger_46.ewp</path>
  </project>
  <batchBuild />
</workspace>
